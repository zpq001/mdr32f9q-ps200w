# Keil uVision project MDR_200W.uvproj, settings and files
target RAM (ARM-ADS)
  device: MDR32F9Q2I milandr
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MDR_200W
  c flags: Optim=1
  c include: .\;.\src;.\src\fonts;..\Library\Libraries\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc;..\Library\Libraries\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\arm;..\Library\Libraries\MDR32F9Qx_StdPeriph_Driver\inc;..\Library\FreeRTOSV7.5.3\FreeRTOS\Source\portable\RVDS\ARM_CM3\;..\Library\FreeRTOSV7.5.3\FreeRTOS\Source;..\Library\FreeRTOSV7.5.3\FreeRTOS\Source\include
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x6000
  memory RVCT9: RAM 0x20006000 size 0x2000
  group Startup
    ./: startup_MDR32F9x.s
    ../Library/Libraries/CMSIS/CM3/DeviceSupport/MDR32F9Qx/startup/arm/: system_MDR32F9Qx.c
  group lib
    ../Library/Libraries/MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_rst_clk.c MDR32F9Qx_ssp.c MDR32F9Qx_port.c MDR32F9Qx_timer.c MDR32F9Qx_i2c.c MDR32F9Qx_adc.c MDR32F9Qx_uart.c MDR32F9Qx_dma.c
  group src
    ./: main.c
    ./src/: systemfunc.c systick.c lcd_1202.c buttons.c led.c encoder.c i2c_eeprom.c dwt_delay.c control.c lcd_func.c converter.c gui_top.c service.c dispatcher.c adc.c uart.c sound_driver.c sound_samples.c
  group fonts
    ./src/fonts/: fonts.h font_defs.h font_8x12.c font_32x19.c font_16x10.c image_defs.h images.h images.c
  group FreeRTOS
    ./: FreeRTOSConfig.h
    ../Library/FreeRTOSV7.5.3/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c portmacro.h
    ../Library/FreeRTOSV7.5.3/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../Library/FreeRTOSV7.5.3/FreeRTOS/Source/portable/MemMang/: heap_4.c
target FLASH (ARM-ADS)
  device: MDR32F9Q2I milandr
  cpu: as above
  output: MDR_200W +hex
  c flags: Optim=2
  c include: .\src\fonts;.\;.\src;..\Library\Libraries\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc;..\Library\Libraries\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\arm;..\Library\Libraries\MDR32F9Qx_StdPeriph_Driver\inc;..\Library\FreeRTOSV7.5.3\FreeRTOS\Source\portable\RVDS\ARM_CM3\;..\Library\FreeRTOSV7.5.3\FreeRTOS\Source;..\Library\FreeRTOSV7.5.3\FreeRTOS\Source\include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
