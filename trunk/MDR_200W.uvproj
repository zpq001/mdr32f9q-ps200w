# Keil uVision project MDR_200W.uvproj, settings and files
target RAM (ARM-ADS)
  device: MDR32F9Q2I milandr
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MDR_200W
  c flags: Optim=1
  c include: .\;.\src;.\src\fonts;..\Library\Libraries\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc;..\Library\Libraries\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\arm;..\Library\Libraries\MDR32F9Qx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x6000
  memory RVCT9: RAM 0x20006000 size 0x2000
  group Startup
    ./: startup_MDR32F9x.s
    ../Library/Libraries/CMSIS/CM3/DeviceSupport/MDR32F9Qx/startup/arm/: system_MDR32F9Qx.c
  group lib
    ../Library/Libraries/MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_rst_clk.c MDR32F9Qx_ssp.c MDR32F9Qx_port.c MDR32F9Qx_timer.c MDR32F9Qx_i2c.c MDR32F9Qx_adc.c
  group src
    ./: main.c
    ./src/: systemfunc.c systick.c lcd_1202.c buttons.c led.c encoder.c i2c_eeprom.c dwt_delay.c control.c lcd_func.c converter.c
  group fonts
    ./src/fonts/: fonts.h font_defs.h font_8x12.c font_32x19.c font_16x10.c image_defs.h images.h images.c
target FLASH (ARM-ADS)
  device: MDR32F9Q2I milandr
  cpu: as above
  output: MDR_200W +hex
  c flags: Optim=1
  c include: .\src\fonts;..\MDR_200W;.\src;..\Library\Libraries\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc;..\Library\Libraries\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\arm;..\Library\Libraries\MDR32F9Qx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
